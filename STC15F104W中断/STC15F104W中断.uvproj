# Keil uVision project STC15F104W中断.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W Series STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: STC15F104W中断 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\libs
  group Source Group 1
    ./: STARTUP.A51 STC15F104W中断.c
  group libs
    ../libs/: sys_delay_ms.c
