# Keil uVision project 51定时器应用.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C1051 Microchip
  cpu: IRAM(0 - 0x3F) IROM(0 - 0x3FF) CLOCK(24000000)
  output: 51单片机定时器应用 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: times.c
