# Keil uVision project 51单键开关.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 单片机开关 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: control.c
